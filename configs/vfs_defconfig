## lib/Kconfig
```kconfig
config VFAT
	bool "Enable vfat functions"
	default n
	help
	  Say Y if you want to enable log functions.
```
